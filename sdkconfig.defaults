## sdkconfig.defaults
```kconfig
# Override defaults here
CONFIG_MBEDTLS_DEBUG=y


#
# ESP32-specific config
#

#CONFIG_ESP32_DEFAULT_CPU_FREQ_160=y
#CONFIG_ESP32_DEFAULT_CPU_FREQ_MHZ=160
```
